<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\DSTII\LABB1\labb1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\labb3\labb3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\projekt.ewp</path>
    </project>
    <batchBuild />
</workspace>
