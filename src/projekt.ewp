# IAR project projekt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: projekt.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Microchip\sam3x8\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: at91sam3x8.h core_cm3.h core_cmFunc.h core_cmInstr.h cstartup.s dateTime.c dateTime.h exceptions.c exceptions.h getKey.c getKey.h led.c led.h LinkedList.c LinkedList.h main.c printTemp.c printTemp.h readLight.c readLight.h readTemp.c readTemp.h servo.c servo.h startup_sam3x.c structs.h system_sam3x.c system_sam3x.h Write2Display.c Write2Display.h
